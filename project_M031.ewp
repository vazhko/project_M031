# IAR project project_M031.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: Library\Device\Nuvoton\M031\Include; Library\CMSIS\Include; Library\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: project_M031.hex
  ILINK.IlinkOutputFile: project_M031r.out
  ILINK.IlinkIcfFile: project_M031.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library Files
    Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group Source Files
    ./: main.cpp
